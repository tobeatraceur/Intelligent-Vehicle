# Keil uVision project IO_TEST.uvproj, settings and files
target QiZhiRobot (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: WP_ALL
  AfterMake: D:\program\Keil\ARM\ARMCC\bin\fromelf.exe "..\Project\List\WP_ALL.axf" --bin --output "..\Project\List\WP_ALL.bin"
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\User;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\eMPL;..\User\Shell
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group USER
    ../User/: main.c Wp_ADC.c Wp_Globle.c Wp_UART.c Wp_IIC.c Wp_OLED.c Wp_GPIO.c Wp_HallSensor.c Wp_MPU6050.c Wp_it.c Wp_NVIC.c Wp_Sys.c Wp_TIMER.c Wp_EXTI.c Queue.c Wp_Key.c Wp_Ble.c Wp_Motor.c stdlib.c Wp_Pwm.c Wp_25F16.c Wp_Flash.c Wp_Dma.c
    ../User/Protocol/: UpRobot.c
    ../User/Shell/: CmdParse.c
    ./: Location.c
  group LIBRARIES
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c misc.c stm32f10x_gpio.c stm32f10x_wwdg.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group eMEL
    ../eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
